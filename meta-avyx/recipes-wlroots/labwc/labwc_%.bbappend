# Do not build GTK3 helper tools (labwc-tweaks, menu generator) just because they are "recommended".
RRECOMMENDS:${PN} = "foot grim slurp wl-clipboard swaybg"
